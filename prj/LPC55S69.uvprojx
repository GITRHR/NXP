# Keil uVision project LPC55S69.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.1.0
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: LPC55S69
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-missing-variable-declarations  -Wno-missing-noreturn  -Wno-conditional-uninitialized  -Wno-missing-braces  -Wno-undef  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code-return  -Wno-float-equal  -Wno-unused-variable  -Wno-double-promotion  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-extra-semi-stmt  -Wno-array-bounds  -Wno-gcc-compat
  c include: ..\CMSIS;..\CMSIS\Driver;..\CMSIS\Include;..\core;..\lib\inc;..\user;..\drivers\uart;..\drivers\utilities\debug_console;..\drivers\utilities\str;..\drivers\utilities;..\drivers\serial_manager;..\drivers\lcd;..\drivers\as608;..\drivers\PAJ7620U2;..\drivers\MAX30102;..\drivers\SIM800A
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x4000000 size 0x8000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: .\LPC55S69_cm33_core0_flash.scf
  link misc: C:\Users\HR\Desktop\MCU-Project\core\keil_lib_power_cm33_core0.lib --remove
  group user
    ../user/: board.c clock_config.c pin_mux.c main.c
  group core
    ../core/: system_LPC55S69_cm33_core0.c startup_LPC55S69_cm33_core0.s
  group lib
    ../lib/src/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_iap.c fsl_inputmux.c fsl_lpadc.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_power.c fsl_powerquad_basic.c fsl_powerquad_cmsis.c fsl_powerquad_data.c fsl_powerquad_filter.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_transform.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_rng.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_sysctl.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
  group driver
    ../drivers/uart/: usart_adapter.c
    ../drivers/utilities/: fsl_assert.c
    ../drivers/utilities/str/: fsl_str.c
    ../drivers/utilities/debug_console/: fsl_debug_console.c
    ../drivers/serial_manager/: serial_manager.c serial_port_uart.c
    ../drivers/lcd/: GUI.c Lcd_Driver.c QDTFT_demo.c
    ../drivers/as608/: as608.c
    ../drivers/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../drivers/SIM800A/: SIM800A.c
